# Keil uVision project GLCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: RT_UPI_GSM_WIFI_MCU_D260424_V1_0 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Library\Device\Include;.\Library\StdDriver\inc;.\Library\User;.\Library\User
  group Source Group 1
    ./: STARTUP.A51
  group Main
    ./: Main.c
  group Common
    ./User_C_Files/: GLCD.c
    ./Library/StdDriver/src/: uart.c RGsm_At.c RDataFlash.c RTimer0.c
